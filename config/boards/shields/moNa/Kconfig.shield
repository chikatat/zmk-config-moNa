## config/boards/shields/moNa/Kconfig.shield
```kconfig
config SHIELD_SOBA_R
    def_bool $(shields_list_contains,soba_R)

config SHIELD_SOBA_L
    def_bool $(shields_list_contains,soba_L)
```
